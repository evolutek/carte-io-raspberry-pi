# Repository evolutek/carte-io-raspberry-pi

## EAGLE design CarteIO Beacon V1/Board.brd

Parts:
5V, 12V: RED; CHIP-LED0805
C1: 330uF; E5-10,5
C2: 2.2uF; C0603
C3, C4: 22pF; C0603
C5, C6: 100nF; C0603
CAN1, CAN2: JST4; B04B-PASK
D1: MBR60H100CTG; TO220ABS
F1: FUSE
FAN: JST2; B02B-PASK
IN_12V: 2604-3102; P-2604-3102
LEDS: JST3; B03B-PASK
Q1: 16MHz; HC49/S
R1: 21K; R0603
R2: 120; R0603
R3: 10k; R0603
R4: 21k; R0603
R5: 4.7k; R0603
R6, R8, R11: 510; R0603
R7, R9, R10: 150; R0603
R12, R13: 68; R0603
S1, S2: JST3; B03B-PASK
S1., S2.: GREEN; CHIP-LED0805
SV1: J1; FE20-2
U$1: PTN78020WAD
U$2: MCP2515-I/SO; SOIC127P1030X265-18N
U$3: MCP2551-I/SN; SOIC127P599X175-8N
X1: PN87520

Connections:
+3V3: R5.1, SV1.1, SV1.17, U$2.18 (VDD)
+5V: 5V.A, C1.+, C5.1, C6.2, CAN1.P$1 (1), CAN2.P$1 (1), LEDS.P$1 (1), SV1.2, SV1.4, U$1.5 (SENSE), U$1.6 (VO), U$3.3 (VDD), X1.1
+12V: 12V.A, C2.1, F1.P$1 (1), F1.P$2 (1), FAN.P$1 (1), S1.P$1 (1), S2.P$1 (1), U$1.2 (VI)
CS: SV1.24, U$2.16 (!CS)
GND: C1.-, C2.2, C3.2, C4.2, C5.2, C6.1, CAN1.P$4 (4), CAN2.P$4 (4), D1.A1, FAN.P$2 (2), IN_12V.P2.1, IN_12V.P2.2, LEDS.P$3 (3), R1.1, R4.2, R7.2, R9.1, R10.2, R11.1, R12.2, R13.1, S1.P$3 (3), S2.P$3 (3), SV1.6, SV1.9, SV1.14, SV1.20, SV1.25, SV1.30, SV1.34, SV1.39, U$1.1 (GND), U$1.7 (GND_S), U$2.9 (VSS), U$3.2 (VSS), U$3.8 (RS), X1.4
LEDS: LEDS.P$2 (2), SV1.32
MISO: SV1.21, U$2.15 (SO)
MOSI: SV1.19, U$2.14 (SI)
unnamed: R6.1, S1.P$2 (2)
unnamed: R1.2, U$1.4 (ADJUST)
unnamed: CAN1.P$2 (2), CAN2.P$2 (2), R2.1, U$3.6 (CANL)
unnamed: CAN1.P$3 (3), CAN2.P$3 (3), R2.2, U$3.7 (CANH)
unnamed: R8.1, S2.P$2 (2)
unnamed: C4.1, Q1.1, U$2.8 (OSC1)
unnamed: R13.2, S1..C
unnamed: 5V.C, R9.2
unnamed: R3.2, U$2.2 (RXCAN)
unnamed: 12V.C, R11.2
unnamed: R12.1, S2..C
unnamed: D1.C, F1.P$3 (2), F1.P$4 (2), IN_12V.P1.1, IN_12V.P1.2
unnamed: R3.1, R4.1, U$3.4 (RXD)
unnamed: R5.2, U$2.17 (!RESET)
unnamed: U$2.1 (TXCAN), U$3.1 (TXD)
unnamed: C3.1, Q1.2, U$2.7 (OSC2)
SCK: SV1.23, U$2.13 (SCK)
SENSOR1: R6.2, R7.1, S1..A, SV1.16
SENSOR2: R8.2, R10.1, S2..A, SV1.18

Notes on the sheet:
POWER IN
LEDS POWER
GPIOS RASPBERRY
Carte IO Beacon V1.0
FAN
CAN BUS
LED STRIP
SENSOR
REDUCTION 5V
ROUTER POWER

Board: 2 copper layers, 97.9 x 56.8 mm, 38 parts (7 on the bottom side), 27 nets.

## EAGLE design CarteIO V3/Board.brd

Parts:
3.3V, 5V, 12V: LEDCHIP-LED0805; CHIP-LED0805
BAU: LEDCHIP-LED0805; CHIP-LED0805
C1, C2, C3, C4, C5, C6: 0.1uF; C0603
COLOR1, COLOR2, COLOR3, COLOR4: JST4; B04B-PASK
D1: 1N821; DO35Z10
GPIO10: LEDCHIP-LED0805; CHIP-LED0805
IN_5V, IN_12V: 2604-3102; P-2604-3102
LEDS: JST3; B03B-PASK
LED_TIRETTE: LEDCHIP-LED0805; CHIP-LED0805
MDB: JST5; B05B-PASK
P0, P1: LEDCHIP-LED0805; CHIP-LED0805
PUMP1, PUMP2, PUMP3, PUMP4, PUMP5, PUMP6, PUMP7, PUMP8: JST4; B04B-PASK
PWM0, PWM1: JST3; B03B-PASK
R1, R2, R10, R12, R13, R14, R15, R26: 68; R0603
R3, R4: 4.7k; R0603
R5, R6, R7, R8: 10k; R0603
R9: 150; R0603
R11: 510; R0603
R16: 1k; R0603
R17: 300; R0603
RX: LEDCHIP-LED0805; CHIP-LED0805
SV1: J1; FE20-2
SW1: SW_DIP-3; EDG-03
TIRETTE: JST3; B03B-PASK
TX: LEDCHIP-LED0805; CHIP-LED0805
U1: MAX3232EID; SOIC127P600X175-16N
U2: TCA9548APWR; SOP65P640X120-24N
VCC_IN: JST2; B02B-PASK
X1: D-SUB9-H5M09RA; H5M09RA

Connections:
+3V3: 3.3V.A, C1.1, C6.1, COLOR1.P$1 (1), COLOR2.P$1 (1), COLOR3.P$1 (1), COLOR4.P$1 (1), MDB.P$1 (1), PWM0.P$1 (1), PWM1.P$1 (1), R3.1, R4.1, R5.1, SV1.1, SV1.17, SW1.1, SW1.2, SW1.3, TIRETTE.P$1 (1), U1.16 (VCC), U2.24 (VCC)
+5V: 5V.A, D1.C, IN_5V.P1.1, IN_5V.P1.2, LEDS.P$1 (1), SV1.2, SV1.4
+12V: 12V.A, IN_12V.P1.1, IN_12V.P1.2, PUMP1.P$1 (1), PUMP2.P$1 (1), PUMP3.P$1 (1), PUMP4.P$1 (1), PUMP5.P$1 (1), PUMP6.P$1 (1), PUMP7.P$1 (1), PUMP8.P$1 (1), R16.1
EV1: PUMP1.P$3 (3), SV1.12
EV2: PUMP2.P$3 (3), SV1.16
EV3: PUMP3.P$3 (3), SV1.18
EV4: PUMP4.P$3 (3), SV1.22
EV5: PUMP5.P$3 (3), SV1.24
EV6: PUMP6.P$3 (3), SV1.26
EV7: PUMP7.P$3 (3), SV1.36
EV8: PUMP8.P$3 (3), SV1.38
GND: C1.2, C2.2, C5.1, C6.2, COLOR1.P$4 (4), COLOR2.P$4 (4), COLOR3.P$4 (4), COLOR4.P$4 (4), D1.A, IN_5V.P2.1, IN_5V.P2.2, IN_12V.P2.1, IN_12V.P2.2, LEDS.P$3 (3), MDB.P$5 (5), PUMP1.P$4 (4), PUMP2.P$4 (4), PUMP3.P$4 (4), PUMP4.P$4 (4), PUMP5.P$4 (4), PUMP6.P$4 (4), PUMP7.P$4 (4), PUMP8.P$4 (4), PWM0.P$3 (3), PWM1.P$3 (3), R1.1, R2.1, R6.2, R7.2, R8.2, R9.1, R10.1, R11.1, R12.2, R13.2, R14.2, R15.2, R17.2, R26.2, SV1.6, SV1.9, SV1.14, SV1.20, SV1.25, SV1.30, SV1.34, SV1.39, TIRETTE.P$3 (3), U1.15 (GND), U2.12 (GND), VCC_IN.P$2 (2), X1.5
GPIO0: SV1.27
GPIO1: SV1.28
GPIO21: BAU.A, R16.2, R17.1, SV1.40
INT_MDB: MDB.P$4 (4), SV1.7
LEDS: GPIO10.A, LEDS.P$2 (2), SV1.19
unnamed: C3.1, U1.1 (C1+)
unnamed: C2.1, U1.2 (V+)
unnamed: C3.2, U1.3 (C1-)
unnamed: C4.1, U1.4 (C2+)
unnamed: C4.2, U1.5 (C2-)
unnamed: C5.2, U1.6 (V-)
unnamed: U1.7 (DOUT2), X1.3
unnamed: R1.2, TX.C
unnamed: 5V.C, R9.2
unnamed: 3.3V.C, R10.2
unnamed: 12V.C, R11.2
unnamed: LED_TIRETTE.C, R26.1
unnamed: R2.2, RX.C
unnamed: BAU.C, R14.1
unnamed: P0.C, R15.1
unnamed: R5.2, U2.3 (!RESET)
unnamed: R8.1, SW1.4, U2.21 (A2)
unnamed: R7.1, SW1.5, U2.2 (A1)
unnamed: R6.1, SW1.6, U2.1 (A0)
unnamed: VCC_IN.P$1 (1), X1.4
unnamed: GPIO10.C, R12.1
unnamed: P1.C, R13.1
PUMP1: PUMP1.P$2 (2), SV1.13
PUMP2: PUMP2.P$2 (2), SV1.15
PUMP3: PUMP3.P$2 (2), SV1.21
PUMP4: PUMP4.P$2 (2), SV1.23
PUMP5: PUMP5.P$2 (2), SV1.29
PUMP6: PUMP6.P$2 (2), SV1.31
PUMP7: PUMP7.P$2 (2), SV1.35
PUMP8: PUMP8.P$2 (2), SV1.37
PWM0: P0.A, PWM0.P$2 (2), SV1.32
PWM1: P1.A, PWM1.P$2 (2), SV1.33
RX: RX.A, SV1.10, U1.9 (ROUT2)
RX_IN: U1.8 (RIN2), X1.2
SCL: MDB.P$3 (3), R3.2, SV1.5, U2.22 (SCL)
SCL0: COLOR1.P$3 (3), U2.5 (SC0)
SCL1: COLOR2.P$3 (3), U2.7 (SC1)
SCL2: COLOR3.P$3 (3), U2.9 (SC2)
SCL3: COLOR4.P$3 (3), U2.11 (SC3)
SDA: MDB.P$2 (2), R4.2, SV1.3, U2.23 (SDA)
SDA0: COLOR1.P$2 (2), U2.4 (SD0)
SDA1: COLOR2.P$2 (2), U2.6 (SD1)
SDA2: COLOR3.P$2 (2), U2.8 (SD2)
SDA3: COLOR4.P$2 (2), U2.10 (SD3)
TIRETTE: LED_TIRETTE.A, SV1.11, TIRETTE.P$2 (2)
TX: SV1.8, TX.A, U1.10 (DIN2)

Notes on the sheet:
POWER IN
LEDS POWER
GPIOS RASPBERRY
PUMPS
SERIAL
I2C MULTIPLEXING
COLOR SENSORS
MDB
OTHER I/O
Carte IO Raspberry Pi V3.2

Board: 2 copper layers, 85.0 x 57.0 mm, 60 parts (1 on the bottom side), 61 nets.

## EAGLE design CarteIO V2/Board.brd

Parts:
3.3V, 5V, 12V: LEDCHIP-LED0805; CHIP-LED0805
C1, C2, C3, C4, C5: 0.1uF; C0603
COUT1, COUT2: 100nf; C0603
D1: 1N821; DO35Z10
G0, G1, G4, G5, G6, G16, G17, G18, G19, G20, G21, G22, G23, G24, G25, G26, G27: LEDCHIP-LED0805; CHIP-LED0805
GPIO0, GPIO1, GPIO4, GPIO5, GPIO6, GPIO16, GPIO17, GPIO18, GPIO19, GPIO20, GPIO21, GPIO22, GPIO23, GPIO24, GPIO25, GPIO26, GPIO27: JST3; B03B-PASK
I2C: JST4; B04B-PASK
IN_5V, IN_12V: WAGO-2604-3304
OUT_3.3V, OUT_5V: WAGO-2604-3304
P0, P1: LEDCHIP-LED0805; CHIP-LED0805
PWM0, PWM1: JST3; B03B-PASK
R1, R3, R5, R7, R9, R11: 265; R0603
R2, R4, R6, R8, R10, R12, R16, R17, R18, R19: 100; R0603
R13: 150; R0603
R14: 65; R0603
R15: 500; R0603
RX: LEDCHIP-LED0805; CHIP-LED0805
SPI0, SPI1: JST6; B06B-PASK
SV1: J1; FE20-2
TX: LEDCHIP-LED0805; CHIP-LED0805
U1: MAX3232CUE; 21-0066J_16
X1: D-SUB9-H5M09RA; H5M09RA

Connections:
+3V3: 3.3V.A, C1.1, COUT2.1, GPIO0.P$1 (1), GPIO1.P$1 (1), GPIO4.P$1 (1), GPIO5.P$1 (1), GPIO6.P$1 (1), GPIO17.P$1 (1), GPIO19.P$1 (1), GPIO22.P$1 (1), GPIO25.P$1 (1), GPIO26.P$1 (1), GPIO27.P$1 (1), I2C.P$1 (1), OUT_3.3V.P$1 (+), OUT_3.3V.P$2 (+), PWM0.P$1 (1), PWM1.P$1 (1), SPI0.P$1 (1), SPI1.P$1 (1), SV1.1, SV1.17, U1.16 (VCC)
+5V: 5V.A, COUT1.1, D1.C, IN_5V.P$1 (+), IN_5V.P$2 (+), OUT_5V.P$1 (+), OUT_5V.P$2 (+), SV1.2, SV1.4
+12V: 12V.A, GPIO16.P$1 (1), GPIO18.P$1 (1), GPIO20.P$1 (1), GPIO21.P$1 (1), GPIO23.P$1 (1), GPIO24.P$1 (1), IN_12V.P$1 (+), IN_12V.P$2 (+)
CE0: SPI0.P$6 (6), SV1.24
CE1: SPI1.P$6 (6), SV1.26
GND: C1.2, C2.2, C5.1, COUT1.2, COUT2.2, D1.A, G0.C, G1.C, G4.C, G5.C, G6.C, G16.C, G17.C, G18.C, G19.C, G20.C, G21.C, G22.C, G23.C, G24.C, G25.C, G26.C, G27.C, GPIO0.P$2 (2), GPIO1.P$2 (2), GPIO4.P$2 (2), GPIO5.P$2 (2), GPIO6.P$2 (2), GPIO16.P$2 (2), GPIO17.P$2 (2), GPIO18.P$2 (2), GPIO19.P$2 (2), GPIO20.P$2 (2), GPIO21.P$2 (2), GPIO22.P$2 (2), GPIO23.P$2 (2), GPIO24.P$2 (2), GPIO25.P$2 (2), GPIO26.P$2 (2), GPIO27.P$2 (2), I2C.P$2 (2), IN_5V.P$3 (-), IN_5V.P$4 (-), IN_12V.P$3 (-), IN_12V.P$4 (-), OUT_3.3V.P$3 (-), OUT_3.3V.P$4 (-), OUT_5V.P$3 (-), OUT_5V.P$4 (-), PWM0.P$2 (2), PWM1.P$2 (2), R2.1, R4.1, R6.1, R8.1, R10.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.2, R19.2, SPI0.P$2 (2), SPI1.P$2 (2), SV1.6, SV1.9, SV1.14, SV1.20, SV1.25, SV1.30, SV1.34, SV1.39, U1.15 (GND), X1.5
GPIO0: G0.A, GPIO0.P$3 (3), SV1.27
GPIO1: G1.A, GPIO1.P$3 (3), SV1.28
GPIO4: G4.A, GPIO4.P$3 (3), SV1.7
GPIO5: G5.A, GPIO5.P$3 (3), SV1.29
GPIO6: G6.A, GPIO6.P$3 (3), SV1.31
GPIO16: G16.A, R7.1, R8.2, SV1.36
GPIO17: G17.A, GPIO17.P$3 (3), SV1.11
GPIO18: G18.A, R1.1, R2.2, SV1.12
GPIO19: G19.A, GPIO19.P$3 (3), SV1.35
GPIO20: G20.A, R9.1, R10.2, SV1.38
GPIO21: G21.A, R11.1, R12.2, SV1.40
GPIO22: G22.A, GPIO22.P$3 (3), SV1.15
GPIO23: G23.A, R3.1, R4.2, SV1.16
GPIO24: G24.A, R5.1, R6.2, SV1.18
GPIO25: G25.A, GPIO25.P$3 (3), SV1.22
GPIO26: G26.A, GPIO26.P$3 (3), SV1.37
GPIO27: G27.A, GPIO27.P$3 (3), SV1.13
MISO: SPI0.P$5 (5), SPI1.P$5 (5), SV1.21
MOSI: SPI0.P$4 (4), SPI1.P$4 (4), SV1.19
unnamed: C3.1, U1.1 (C1+)
unnamed: C2.1, U1.2 (V+)
unnamed: C3.2, U1.3 (C1-)
unnamed: C4.1, U1.4 (C2+)
unnamed: C4.2, U1.5 (C2-)
unnamed: C5.2, U1.6 (V-)
unnamed: U1.13 (R1IN), X1.3
unnamed: U1.14 (T1OUT), X1.2
unnamed: 5V.C, R13.2
unnamed: 3.3V.C, R14.2
unnamed: 12V.C, R15.2
unnamed: R16.2, TX.C
unnamed: R17.2, RX.C
unnamed: GPIO18.P$3 (3), R1.2
unnamed: GPIO23.P$3 (3), R3.2
unnamed: GPIO24.P$3 (3), R5.2
unnamed: GPIO16.P$3 (3), R7.2
unnamed: GPIO20.P$3 (3), R9.2
unnamed: GPIO21.P$3 (3), R11.2
unnamed: P0.C, R18.1
unnamed: P1.C, R19.1
PWM0: P0.A, PWM0.P$3 (3), SV1.32
PWM1: P1.A, PWM1.P$3 (3), SV1.33
RX: RX.A, SV1.10, U1.12 (R1OUT)
SCL: I2C.P$4 (4), SV1.5
SCLK: SPI0.P$3 (3), SPI1.P$3 (3), SV1.23
SDA: I2C.P$3 (3), SV1.3
TX: SV1.8, TX.A, U1.11 (T1IN)

Board: 2 copper layers, 85.0 x 58.5 mm, 80 parts (1 on the bottom side), 53 nets.

## EAGLE design CarteIO V1/Board.brd

Parts:
3.3V, 5V: WAGO-2604-3304
C1, C2, C3, C4, C5: 0.1uF; C0603
CCOMP: 15nF; C0603
CIN, CIN1: 10uF; C0603
COUT1, COUT2: 100nf; C0603
CSS: 47nF; C0603
D1: 1N821; DO35Z10
D2: B540C-13-F
GPIO0, GPIO1, GPIO4, GPIO5, GPIO6, GPIO17, GPIO19, GPIO22, GPIO25, GPIO26, GPIO27: JST3; B03B-PASK
GTB1, GTB2, GTB3, GTB4, GTB5, GTB6: JST3; B03B-PASK
I2C: JST4; B04B-PASK
J1: JST7; B07B-PASK
L1: 4.7uH; XAL4030-472MEB
POWER-IN: WAGO-2604-3304
PWM0, PWM1: JST3; B03B-PASK
R1, R3, R5, R7, R9, R11: 265; R0603
R2, R4, R6, R8, R10, R12: 100; R0603
RCOMP: 2.94K; R0603
RFBB: 16.2K; R0603
RFBT: 143K; R0603
RT: 100k; R0603
SV1: J1; FE20-2
U1: MAX3232CUE; 21-0066J_16
U2: TPS61175PWPR; SOP65P640X120-15N
X1: D-SUB9-H5M09RA; H5M09RA

Connections:
+3V3: 3.3V.P$1 (+), 3.3V.P$2 (+), C1.1, COUT2.1, GPIO0.P$1 (1), GPIO1.P$1 (1), GPIO4.P$1 (1), GPIO5.P$1 (1), GPIO6.P$1 (1), GPIO17.P$1 (1), GPIO19.P$1 (1), GPIO22.P$1 (1), GPIO25.P$1 (1), GPIO26.P$1 (1), GPIO27.P$1 (1), I2C.P$1 (1), J1.P$1 (1), PWM0.P$1 (1), PWM1.P$1 (1), SV1.1, SV1.17, U1.16 (VCC)
+5V: 5V.P$1 (+), 5V.P$2 (+), CIN.1, COUT1.1, D1.C, L1.P$1, POWER-IN.P$1 (+), POWER-IN.P$2 (+), SV1.2, SV1.4, U2.3 (VIN), U2.4 (EN)
+12V: CIN1.1, D2.C (B), GTB1.P$1 (1), GTB2.P$1 (1), GTB3.P$1 (1), GTB4.P$1 (1), GTB5.P$1 (1), GTB6.P$1 (1), RFBT.2
CE0: J1.P$6 (6), SV1.24
CE1: J1.P$7 (7), SV1.26
FB: RFBB.2, RFBT.1, U2.9 (FB)
GND: 3.3V.P$3 (-), 3.3V.P$4 (-), 5V.P$3 (-), 5V.P$4 (-), C1.2, C2.2, C5.1, CCOMP.2, CIN.2, CIN1.2, COUT1.2, COUT2.2, CSS.2, D1.A, GPIO0.P$2 (2), GPIO1.P$2 (2), GPIO4.P$2 (2), GPIO5.P$2 (2), GPIO6.P$2 (2), GPIO17.P$2 (2), GPIO19.P$2 (2), GPIO22.P$2 (2), GPIO25.P$2 (2), GPIO26.P$2 (2), GPIO27.P$2 (2), GTB1.P$2 (2), GTB2.P$2 (2), GTB3.P$2 (2), GTB4.P$2 (2), GTB5.P$2 (2), GTB6.P$2 (2), I2C.P$2 (2), J1.P$2 (2), POWER-IN.P$3 (-), POWER-IN.P$4 (-), PWM0.P$2 (2), PWM1.P$2 (2), R2.1, R4.1, R6.1, R8.1, R10.1, R12.1, RFBB.1, RT.2, SV1.6, SV1.9, SV1.14, SV1.20, SV1.25, SV1.30, SV1.34, SV1.39, U1.15 (GND), U2.6 (SYNC), U2.7 (AGND), U2.12 (PGND_2), U2.13 (PGND_3), U2.14 (PGND), U2.15 (EPAD)
GPIO0: GPIO0.P$3 (3), SV1.27
GPIO1: GPIO1.P$3 (3), SV1.28
GPIO4: GPIO4.P$3 (3), SV1.7
GPIO5: GPIO5.P$3 (3), SV1.29
GPIO6: GPIO6.P$3 (3), SV1.31
GPIO16: R7.1, R8.2, SV1.36
GPIO17: GPIO17.P$3 (3), SV1.11
GPIO18: R1.1, R2.2, SV1.12
GPIO19: GPIO19.P$3 (3), SV1.35
GPIO20: R9.1, R10.2, SV1.38
GPIO21: R11.1, R12.2, SV1.40
GPIO22: GPIO22.P$3 (3), SV1.15
GPIO23: R3.1, R4.2, SV1.16
GPIO24: R5.1, R6.2, SV1.18
GPIO25: GPIO25.P$3 (3), SV1.22
GPIO26: GPIO26.P$3 (3), SV1.37
GPIO27: GPIO27.P$3 (3), SV1.13
MISO: J1.P$5 (5), SV1.21
MOSI: J1.P$4 (4), SV1.19
unnamed: C3.1, U1.1 (C1+)
unnamed: C2.1, U1.2 (V+)
unnamed: C3.2, U1.3 (C1-)
unnamed: C4.1, U1.4 (C2+)
unnamed: C4.2, U1.5 (C2-)
unnamed: C5.2, U1.6 (V-)
unnamed: U1.13 (R1IN), X1.2
unnamed: U1.14 (T1OUT), X1.3
unnamed: D2.A, L1.P$2, U2.2 (SW)
unnamed: RT.1, U2.10 (FREQ)
unnamed: RCOMP.1, U2.8 (COMP)
unnamed: CCOMP.1, RCOMP.2
unnamed: CSS.1, U2.5 (SS)
unnamed: GTB1.P$3 (3), R1.2
unnamed: GTB2.P$3 (3), R3.2
unnamed: GTB3.P$3 (3), R5.2
unnamed: GTB4.P$3 (3), R7.2
unnamed: GTB5.P$3 (3), R9.2
unnamed: GTB6.P$3 (3), R11.2
PWM0: PWM0.P$3 (3), PWM1.P$3 (3), SV1.32
PWM1: SV1.33
RX: SV1.10, U1.12 (R1OUT)
SCL: I2C.P$4 (4), SV1.5
SCLK: J1.P$3 (3), SV1.23
SDA: I2C.P$3 (3), SV1.3
TX: SV1.8, U1.11 (T1IN)

Board: 2 copper layers, 85.0 x 58.5 mm, 58 parts (1 on the bottom side), 51 nets.

## Commit log

2019-01-08 Add Lib
2019-01-08 Add Carte IO V1
2019-01-09 Add Components in the lib
2019-01-09 Add 12V regulator on the sch
2019-01-09 Add components to the lib
2019-01-09 Add GTB ports
2019-01-09 Add txt file for gpio
2019-01-11 Finish Schematics
2019-01-11 Pcb not finished
2019-01-15 PCB is done, need to check serial connector
2019-01-15 Update gitignore
2019-01-15 Finish Board and remove useless files
2019-01-15 Add Documentation
2019-03-12 Add Carte IO v2
2019-03-12 Add leds and correct mistakes on serial connection
2019-03-12 Add JST6 and correct wago connector
2019-03-14 Add V2 of the IO board
2019-03-17 Clean files and add Gerber files for V2
2019-12-26 Update Lib
2019-12-26 [V3] Add a new version, need to check and make 3D model
2019-12-28 [V3] Add 3D model, card checked
2020-01-24 [V3.0] Release
2020-01-24 [3.0] Release
2020-03-21 [3.2] Release
2020-03-29 [V3.2] Patch error on PCB
2020-04-10 [V3.2] Change led strip port and add a color sensor port
2020-04-16 [V3.2] Correct a bad routing on color sensor 1
2020-04-20 [V3.2] Correct I2C Multiplexer rooting
2020-09-04 CarteIO Beacon V1 + Add lib SEAL
2020-09-18 Added PDFs for Beacon shield
2021-01-03 Started shield IO v4
2021-01-03 Schematic almost done
2021-01-05 Started second disposition
2021-01-05 CarteIO V4 PCB almost done
2021-01-07 Third version of the shield IO v4
2021-01-07 Planes improvements
2021-01-07 Some fixes on V4.0 board
2021-01-12 Fixes
2021-01-14 Added 3.3V LDO + Lidar connector
2021-01-24 Added buzzer and power board conn, started rerouting
2021-01-24 Add 3D model of the V4.0
2021-01-25 Bottom of the PCB done
2021-01-28 Shield IO V4 done
2021-01-31 Bom, gerber, pdf, step
2021-02-28 Big 5V to CAN + Fixed bicolor led
2021-03-28 Pulldown Buzzer pin
2021-03-29 Shield V4.1
2021-03-31 Fixes V1.1 + 3rd CAN
2021-04-01 Release V4.1
2021-04-05 Add CarteIO Beacon V2
2021-04-05 Update production files
2021-04-05 Update production file for V4
2021-04-05 Update production file for CarteIO Beacon V2
2021-04-06 Minor fix
2022-03-16 Release V5
2022-05-01 Fix V5
2022-06-15 Add bom
2023-03-04 Wip V6
2023-03-05 Wip V6.0
2023-03-06 First version of V6.0
2023-03-08 Add comment in schematics and add CM logo
2023-03-08 Release V6.0
2023-03-15 Fix bom
2023-07-21 Carte IO Beacon V3.1
2023-07-29 Add Camera Aux connector to Carte IO Beacon V3
2023-08-18 Add jumper to select output voltage of the Camera Aux connector
2023-08-18 Add filtering for connected signal
2024-03-09 Carte IO Beacon V3.3
2024-03-17 Carte IO V6.1
2024-03-17 Fix prod archive
2024-03-17 Add decoupling on OR gate VCC
2024-03-18 Carte IO Coffee Pot V1.0
2024-03-18 Regenerate schematics
2024-03-22 Fix Panel IO Led mapping
2024-08-18 WIP Carte IO Beacon V4.0
2024-08-19 WIP V4.0
2024-12-14 Release V6.2
2024-12-19 minor tweaks
    BUS EVO connectors are too close to one another
2024-12-19 moved bus evo further appart from eachothr
2026-04-07 Release Carte IO RPI V6.3
2026-04-08 Add missing pulldown resistors
