# Repository evolutek/carte-io-raspberry-pi

## KiCad design CarteIO V6/CarteIO_V6.kicad_pcb

Parts:
AE1: UFL Antenna; 636101111001
C1, C11, C14: 4.7uF; C_0603_1608Metric
C2, C3, C6, C7, C8, C10, C12, C13, C16: 100nF; C_0603_1608Metric
C4, C9: 1uF; C_0603_1608Metric
C5: 100uF; CP_Elec_6.3x7.7
C15: 4.7nF; C_0603_1608Metric
D1: RED; LED_0805_2012Metric
J1: PSU; 66200421022
J2: Fan; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: Serial; B04B-PASK
J4: Power Control; 690367280676
J5: Panel IO; 690367280876
J6: LEDS; B03B-PASK
J7: Sous-Bus; 690367280676
J8: Bus Evo; 690367281076
JP1, JP2, JP3, JP5, JP6: Jumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
LB1: LOGO; logo-evo-micro
LB2: LOGO; Logo Aisler Micro
LB3: Logo Lora; Logo Lora Micro
M1: Fan_30x30mm; 30x30x10_DC_FAN
R1: 1k; R_0603_1608Metric
R2: 33; R_0603_1608Metric
R3, R4, R5: 10k; R_0603_1608Metric
R6, R7: 60; R_0603_1608Metric
U1: MAX3232; TSSOP-16_4.4x5mm_P0.65mm
U2: NCP718xSN330; SOT-23-5
U3: WIO-E5
U4: MCP2518FD-xQBB; DFN-14-1EP_3x4.5mm_P0.65mm_EP1.65x4.25mm
U5: MCP2561FD-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U6: SN74LVC1G32; SOT-23-5
U7: RaspberryPI; Shield_Raspberry_Pi_with_11mm_Header
Y1: 831025559; WE-SPXO_CFPS-39

Connections:
+3.3V: C3.2, C9.1, C10.1, C11.1, C12.1, C16.1, R3.2, R4.2, U1.16 (VCC), U2.5 (OUT), U3.1 (VCC), U4.14 (VDD), U6.5 (VCC), Y1.4 (Vcc)
+5V: C1.1, C4.1, C5.1, C13.2, C14.1, D1.2 (A), J1.2, J2.1, J5.1, J6.1, J7.1, J8.4, J8.5, JP3.3 (B), U2.1 (IN), U2.3 (EN), U5.3 (VDD), U7.2, U7.4
+12V: J1.1, J7.2, J8.6, JP3.1 (A)
/AU: J4.1, J8.1, U7.38
/BUZZER: J5.3, U7.33
/CANH: J4.5, J8.9, JP5.1 (A), R6.1, U5.7 (CANH)
/CANL: J4.6, J8.10, JP6.1 (A), R7.2, U5.6 (CANL)
/CS: U4.13 (~CS), U7.24
/GREEN_LED: J5.5, U7.18
/LEDS: J6.2, U7.32
/MISO: U4.12 (SDO), U7.21
/MOSI: U4.11 (SDI), U7.19
/PW_HOLD: J4.2, U7.29
/RED_LED: J5.6, U7.16
/RESET_HW: J5.2, U6.1 (A); also elsewhere on the board
/RESET_SW: R5.2, U6.2 (B), U7.37
/RS232_RX: JP1.3 (B), U1.8 (R2IN)
/RS232_TX: JP2.3 (B), U1.7 (T2OUT)
/RST: J7.4, J8.8, U6.4 (S), U7.40
/RX_WIO: U3.10 (PB6), U7.28
/SCK: U4.10 (SCK), U7.23
/SCL: JP6.3 (B), U7.5
/SDA: JP5.3 (B), U7.3
/TIRETTE: J5.7, U7.11; also elsewhere on the board
/TX_WIO: U3.9 (PB7), U7.27
/UART_RX: JP1.1 (A), U1.9 (R2OUT), U7.10
/UART_TX: JP2.1 (A), U1.10 (T2IN), U7.8
/~INT_MCP: U4.4 (~INT), U7.22
/~PW_INT: J4.3, U7.31
/~RST_WIO: R4.1, U3.17 (~RST), U7.26
GND: AE1.2 (Shield), C1.2, C3.1, C4.2, C5.2, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.1, C16.2, J1.3, J1.4, J2.2, J3.4, J4.4, J5.8, J6.3, J7.3, J8.3, J8.7, R1.2, R5.1, U1.15 (GND), U2.2 (GND), U3.2 (GND), U3.14 (GND), U3.16 (GND), U3.22 (GND), U4.7 (VSS), U4.15 (VSS), U5.2 (VSS), U5.8 (STBY), U6.3 (GND), U7.6, U7.9, U7.14, U7.20, U7.25, U7.30, U7.34, U7.39, U7.MH (MountingHoles), Y1.2 (GND); also elsewhere on the board
unnamed: AE1.1 (A), U3.15 (RFIO)
unnamed: D1.1 (K), R1.1
unnamed: J3.1, JP3.2 (C)
unnamed: J3.2, JP1.2 (C)
unnamed: J3.3, JP2.2 (C)
unnamed: J7.5, JP5.2 (C)
unnamed: J7.6, JP6.2 (C)
unnamed: JP4.1 (A), R6.2
unnamed: JP4.3 (B), R7.1
unnamed: C15.2, JP4.2 (C), U5.5 (SPLIT)
unnamed: C2.2, U1.1 (C1+)
unnamed: C2.1, U1.3 (C1-)
unnamed: C6.2, U1.4 (C2+)
unnamed: C6.1, U1.5 (C2-)
unnamed: C7.2, U1.2 (VS+)
unnamed: C8.2, U1.6 (VS-)
unnamed: R3.1, U3.24 (PB13~)
unnamed: R2.1, U4.6 (OSC1)
unnamed: U4.2 (RXCAN), U5.4 (RXD)
unnamed: U4.1 (TXCAN), U5.1 (TXD)
unnamed: R2.2, Y1.3 (OUT)

Notes on the sheet:
RS232 Converter
Sous-Bus (CAN/I2C)
Fan
PSU
Power Control
Bus Evo
Serial Port
Raspberry Pi 4
Marking
3.3V Regulator
WIO-E5
Panel IO
LEDS
RESET Circuit

Board: 2 copper layers, 56.0 x 65.0 mm, 63 parts (0 on the bottom side), 52 nets.

Other parts of the board:
R8, R9: 10k; R_0603_1608Metric
kibuzzard-69D45A49: G***; kibuzzard-69D45A49
kibuzzard-69D45ACD: G***; kibuzzard-69D45ACD
kibuzzard-69D45B59: G***; kibuzzard-69D45B59
kibuzzard-69D45B91: G***; kibuzzard-69D45B91
kibuzzard-69D45BDB: G***; kibuzzard-69D45BDB
kibuzzard-69D45BEE: G***; kibuzzard-69D45BEE
kibuzzard-69D45C0C: G***; kibuzzard-69D45C0C
kibuzzard-69D45C22: G***; kibuzzard-69D45C22
kibuzzard-69D45C59: G***; kibuzzard-69D45C59
kibuzzard-69D45C77: G***; kibuzzard-69D45C77

Their connections:
/RESET_HW: R9.2; also elsewhere on the board
/TIRETTE: R8.2; also elsewhere on the board
GND: R8.1, R9.1; also elsewhere on the board

## KiCad design Carte IO Coffee Pot V1/carte-io-coffee-pot.kicad_pcb

Parts:
C1: 100uF; CP_Elec_6.3x7.7
C2, C3, C4, C6, C8: 4.7uF; C_0603_1608Metric
C5, C7: 100nF; C_0603_1608Metric
D1: RED; D_0805_2012Metric
J1: PSU; 66200421022
J2: FAN; B02B-PASK
J3: Panel IO; 690367280876
J4: LEDS; S03B-PASK
J5: Screen; 690367280876
J6: Color bouton; S04B-PASK
M1: Fan_20x20mm; 20x20x10_DC_FAN
Q1: NMOS; SOT-23
R1: 1k; R_0603_1608Metric
R2, R3: 10k; R_0603_1608Metric
U1: SN74LVC1G32; SOT-23-5
U2: RaspberryPI; Shield_Raspberry_Pi_with_11mm_Header

Connections:
+3.3V: C5.2, C8.2, J5.2, J6.4, U1.5 (VCC), U2.1
+5V: C1.1, C3.2, C4.2, D1.2 (A), J1.2, J4.1, U2.2, U2.4
+12V: C2.2, C6.2, J1.1, J2.1, J3.1, J6.1
/BL: J5.8, U2.12
/BUZZER: J3.3, U2.33
/COLOR: C7.2, J6.3, Q1.2 (G), R3.1, U2.35
/DC: J5.6, U2.22
/LEDS: J4.2, U2.32
/LGRE: J3.5, U2.18
/LRED: J3.6, U2.16
/MOSI: J5.4, U2.19
/RST: U1.4 (S), U2.40
/RST_H: J3.2, U1.1 (A)
/RST_S: R2.1, U1.2 (B), U2.37
/SCLK: J5.3, U2.23
/~CS: J5.7, U2.24
/~RST_OLED: J5.5, U2.13
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, J1.3, J1.4, J2.2, J3.8, J4.3, J5.1, Q1.3 (S), R1.2, R2.2, R3.2, U1.3 (GND), U2.6, U2.9, U2.14, U2.20, U2.25, U2.30, U2.34, U2.39, U2.MH (MountingHoles)
unnamed: D1.1 (K), R1.1
unnamed: J6.2, Q1.1 (D)

Notes on the sheet:
Reset circuit
LEDS
OLED Screen
12V Fan
Power Input
Panel IO
Raspnerry Pi
Button needs to be wire in NO

Board: 2 copper layers, 56.0 x 65.0 mm, 29 parts (0 on the bottom side), 20 nets.

Other parts of the board:
kibuzzard-65F8CF4B: G***; kibuzzard-65F8CF4B
kibuzzard-65F8CFA1: G***; kibuzzard-65F8CFA1
kibuzzard-65F8CFB9: G***; kibuzzard-65F8CFB9
kibuzzard-65F478A9: G***; kibuzzard-65F478A9
kibuzzard-65F478C7: G***; kibuzzard-65F478C7
kibuzzard-65F478FE: G***; kibuzzard-65F478FE
kibuzzard-65F47805: G***; kibuzzard-65F47805

## KiCad design CarteIO Beacon V4/CarteIO Beacon V4.kicad_pcb

Board: 2 copper layers, 56.0 x 65.0 mm, 33 parts (0 on the bottom side), 20 nets.

Parts:
C1: 100uF; CP_Elec_6.3x7.7
C2, C3, C5, C6: 4.7uF; C_0603_1608Metric
C4, C7: 100nF; C_0603_1608Metric
D1: RED; D_0805_2012Metric
D2: 3V; D_SOD-523
J1: PSU; 66200421022
J2: FAN; B02B-PASK
J3: Panel IO - Old; 690367281076
J4: Panel IO; 690367280876
J5: Screen; 690367280876
J6: CACA; S04B-PASK
JP1: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
M1: Fan_20x20mm; 20x20x10_DC_FAN
R1: 1K; R_0603_1608Metric
R2, R3, R4: 10K; R_0603_1608Metric
U1: SN74LVC1G32; SOT-23-5
U2: RaspberryPI; Shield_Raspberry_Pi_with_11mm_Header
kibuzzard-65F47AFD: G***; kibuzzard-65F47AFD
kibuzzard-65F47B1F: G***; kibuzzard-65F47B1F
kibuzzard-65F47B56: G***; kibuzzard-65F47B56
kibuzzard-65F47B76: G***; kibuzzard-65F47B76
kibuzzard-65F478A9: G***; kibuzzard-65F478A9
kibuzzard-65F478C7: G***; kibuzzard-65F478C7
kibuzzard-65F478FE: G***; kibuzzard-65F478FE
kibuzzard-65F4786A: G***; kibuzzard-65F4786A
kibuzzard-65F47805: G***; kibuzzard-65F47805
kibuzzard-65F47874: G***; kibuzzard-65F47874

Connections:
+3.3V: C4.2, C6.2, J5.1, U1.5 (VCC), U2.1
+5V: C1.1, C3.2, D1.2 (A), J1.2, JP1.3 (B), U2.2, U2.4
+12V: C2.2, J1.1, J2.1, J3.1, J4.1, JP1.1 (A)
/BUZZER: J3.3, J4.3, U2.33
/CE0: J5.5, U2.22
/CONNECTED: C7.2, D2.1 (K), R3.1, U2.36
/DC: J5.6, U2.24
/LEDS: J6.2, U2.32
/LGRE: J3.9, J4.5, U2.18
/LRED: J3.7, J4.6, U2.16
/MOSI: J5.3, U2.19
/RST: U1.4 (S), U2.40
/RST_H: J3.10, J4.2, U1.1 (A)
/RST_OLED: J5.7, U2.13
/RST_S: R2.1, U1.2 (B), U2.37
/SCLK: J5.4, U2.23
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, D2.2 (A), J1.3, J1.4, J2.2, J3.5, J4.8, J5.2, J6.4, R1.2, R2.2, R4.2, U1.3 (GND), U2.6, U2.9, U2.14, U2.20, U2.25, U2.30, U2.34, U2.39, U2.MH (MountingHoles)
unnamed: D1.1 (K), R1.1
unnamed: C5.2, J6.1, JP1.2 (C)
unnamed: J6.3, R3.2, R4.1

## KiCad design CarteIO V5/CarteIO_V5.kicad_pcb

Parts:
BUS_EVO1, BUS_EVO2: Conn_02x05_Odd_Even; 690367281076
C1, C4, C7, C8, C9, C12, C14: 100nF; C_0603_1608Metric
C2, C6: 1uF; C_0603_1608Metric
C3, C5, C13, C15, C16: 4.7uF; C_0603_1608Metric
C10, C11: 22pF; C_0603_1608Metric
D1, D2, D3: RED; LED_0805_2012Metric
D4, D5: YELLOW; LED_0805_2012Metric
D6: LED_Dual_AACC; WL-SBTW_3528
D7: D; D_SOD-523
D8: GREEN; LED_0805_2012Metric
J1, J11: Conn_01x06_Male; 66200621122
J2: Conn_01x09_Female; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Hou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
J3: LED strip MDB; B03B-PASK
J4, J5: Conn_01x04_Male; B04B-PASK
J6: Conn_01x03_Male; B03B-PASK
J7, J10: I2C; B04B-PASK
J8: Conn_01x02_Male; PinHeader_2x01_P2.54mm_Vertical
J9: LIDAR Power; B02B-PASK
J12: FAN; B02B-PASK
J13: Raspberry pi; Shield_Raspberry_Pi_with_18mm_Header
JP1, JP2, JP3, JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
PanelIO1: Conn_02x05_Odd_Even; 690367281076
Q1: Q_NMOS_GSD; SOT-23
R1: 510; R_0603_1608Metric
R2: 150; R_0603_1608Metric
R3, R4, R5, R8, R11, R13: 68; R_0603_1608Metric
R6, R7: 100; R_0603_1608Metric
R9, R15, R16: 4.7k; R_0603_1608Metric
R10: 10k; R_0603_1608Metric
R12: 22k; R_0603_1608Metric
R14: 120; R_0603_1608Metric
Sensor1, Sensor2: JST4; B04B-PASK
U1: MAX3232; SOIC-16_3.9x9.9mm_P1.27mm
U2: NCP718xSN330; SOT-23-5
U3: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U4: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 16MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3: C4.2, C12.1, D3.2 (A), J6.1, J11.1, JP2.2 (B), JP4.2 (B), JP5.2 (B), PanelIO1.3, R8.1, R9.1, R11.1, R15.2, R16.2, Sensor1.1, Sensor2.1, U1.16 (VCC), U3.18 (VDD); also elsewhere on the board
+5V: BUS_EVO1.1, BUS_EVO1.3, BUS_EVO2.1, BUS_EVO2.3, C5.1, C13.1, C14.2, C15.1, C16.1, D2.2 (A), J1.2, J3.1, J4.1, J5.1, J7.1, J9.1, J10.1, J13.2, J13.4, JP1.1 (A), U4.3 (VDD)
+12V: BUS_EVO1.2, BUS_EVO2.2, C3.1, D1.2 (A), J1.1, J2.4, J12.1, JP3.1 (A), PanelIO1.1; also elsewhere on the board
/CANH: BUS_EVO1.7, BUS_EVO2.7, J4.2, J5.2, J8.2, PanelIO1.2, U4.7 (CANH); also elsewhere on the board
/CANL: BUS_EVO1.9, BUS_EVO2.9, J4.3, J5.3, PanelIO1.4, R14.2, U4.6 (CANL); also elsewhere on the board
/CS: J13.24, U3.16 (~CS)
/INT: J13.22, U3.12 (~INT)
/LEDS: J3.2, J13.32
/LGRE: D6.2 (A2), J13.18, PanelIO1.9; also elsewhere on the board
/LRED: D6.1 (A1), J13.16, PanelIO1.7; also elsewhere on the board
/MISO: J13.21, U3.15 (SO)
/MOSI: J13.19, U3.14 (SI)
/RX: D5.2 (A), J13.10, U1.9 (R2OUT)
/S1A: J13.33, Sensor1.2
/S1B: J13.35, Sensor1.3
/S2A: J13.36, Sensor2.2
/S2B: J13.37, Sensor2.3
/SCK: J13.23, U3.13 (SCK)
/SCL: J7.3, J10.3, J11.3, J13.5, R16.1
/SDA: J7.2, J10.2, J11.2, J13.3, R15.1
/TIRETTE: D8.2 (A), J6.2, J13.11, PanelIO1.6; also elsewhere on the board
/TX: D4.2 (A), J13.8, U1.10 (T2IN)
/~AU: BUS_EVO1.8, BUS_EVO2.8, D7.1 (K), J13.38
/~PH: J11.5, J13.29
/~PW_INT: J11.4, J13.31
/~RST: BUS_EVO1.10, BUS_EVO2.10, J13.40, PanelIO1.10; also elsewhere on the board
GND: BUS_EVO1.5, BUS_EVO1.6, BUS_EVO2.5, BUS_EVO2.6, C2.2, C3.2, C4.1, C5.2, C6.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, J1.4, J1.5, J1.6, J2.5, J3.3, J4.4, J5.4, J6.3, J7.4, J9.2, J10.4, J11.6, J12.2, J13.6, J13.9, J13.14, J13.20, J13.25, J13.30, J13.34, J13.39, PanelIO1.5, Q1.2 (S), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R12.2, R13.2, Sensor1.4, Sensor2.4, U1.15 (GND), U2.2 (GND), U3.9 (VSS), U4.2 (VSS), U4.8 (Rs); also elsewhere on the board
unnamed: BUS_EVO1.4, BUS_EVO2.4, JP5.1 (A)
unnamed: C1.1, U1.3 (C1-)
unnamed: C1.2, U1.1 (C1+)
unnamed: C2.1, JP1.2 (B), JP3.2 (B), U2.1 (IN), U2.3 (EN)
unnamed: C6.1, JP4.1 (A), U2.5 (OUT)
unnamed: C7.1, U1.5 (C2-)
unnamed: C7.2, U1.4 (C2+)
unnamed: C8.2, U1.2 (VS+)
unnamed: C9.2, U1.6 (VS-)
unnamed: C10.1, U3.8 (OSC1), Y1.1
unnamed: C11.1, U3.7 (OSC2), Y1.2
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: D6.3 (K1), R6.1
unnamed: D6.4 (K2), R7.1
unnamed: D7.2 (A), Q1.1 (G), R11.2
unnamed: D8.1 (K), R13.1
unnamed: J1.3, JP2.1 (A)
unnamed: J2.2, U1.8 (R2IN)
unnamed: J2.3, U1.7 (T2OUT)
unnamed: J8.1, R14.1
unnamed 51: PanelIO1.8, Q1.3 (D), R8.2; also elsewhere on the board
unnamed: R9.2, U3.17 (~RESET)
unnamed: R10.1, R12.1, U4.4 (RXD)
unnamed: R10.2, U3.2 (RXCAN)
unnamed: U3.1 (TXCAN), U4.1 (TXD)

Notes on the sheet:
Power
CAN
Serial
Raspberry pi
Power Control
LIDAR Power
I2C
LED strip MDB
LED Bicolore
Tirette
Fan
Panel IO
BUS EVO
Arm Sensors

Board: 2 copper layers, 56.0 x 85.0 mm, 69 parts (0 on the bottom side), 56 nets.

Other parts of the board:
Panel IO: Conn_02x05_Odd_Even; 690367281076

Their connections:
+3V3: Panel IO.3; also elsewhere on the board
+12V: Panel IO.1; also elsewhere on the board
/CANH: Panel IO.2; also elsewhere on the board
/CANL: Panel IO.4; also elsewhere on the board
/LGRE: Panel IO.9; also elsewhere on the board
/LRED: Panel IO.7; also elsewhere on the board
/TIRETTE: Panel IO.6; also elsewhere on the board
/~RST: Panel IO.10; also elsewhere on the board
GND: Panel IO.5; also elsewhere on the board
unnamed 51: Panel IO.8; also elsewhere on the board

## KiCad design CarteIO Beacon V2/CarteIO Beacon V2.kicad_pcb

Parts:
12V-Battery1: Conn_01x02_Male; 649002227222
C1, C3: 330uF; CP_Radial_D10.0mm_P5.00mm
C2: 2.2uF; C_0603_1608Metric
C4, C5: 1uF; C_0603_1608Metric
C6, C7: 4.7uF; C_0603_1608Metric
D1, D2: RED; LED_0805_2012Metric
D3, D4: GREEN; LED_0805_2012Metric
D5: LED_Dual_AACC; WL-SBTW_3528
J1: Conn_02x20_Odd_Even; ShieldRaspberryPiWithOldHeader
J2: USB_A; USB_A_CONNFLY_DS1095-WNR0
J3, J4: Conn_01x02_Male; B02B-PASK
J5: Conn_01x03_Male; B03B-PASK
Q1: Q_NMOS_GSD; SOT-23
R1, R2, R5: 510; R_0603_1608Metric
R3, R9, R10, R11: 68; R_0603_1608Metric
R4: 10K; R_0603_1608Metric
R6, R7, R8: 150; R_0603_1608Metric
R12, R14: 100; R_0603_1608Metric
R13: 21K; R_0603_1608Metric
S1: WS-TATL_Switch_12x12; 440YS67082622
SENSOR1, SENSOR2: Conn_01x03_Male; B03B-PASK
U1: PTN78060W_EUW-7; Texas_EUW_R-PDSS-T7_THT

Connections:
+3V3: J1.1, R3.1, R4.1
+5V: C3.1, C5.1, C7.1, D2.2 (A), J1.2, J1.4, J2.1 (VBUS), J5.1, U1.5 (VO_Sense), U1.6 (VO)
+12V: 12V-Battery1.1, C1.1, C2.1, C4.1, C6.1, D1.2 (A), J3.1, J4.1, SENSOR1.1, SENSOR2.1, U1.2 (VI)
/LEDS: J1.19, J5.2
/LGREEN: D5.2 (A2), J1.13
/LRED: D5.1 (A1), J1.11
/SENSOR1: D3.2 (A), J1.16, R1.2, R7.1
/SENSOR2: D4.2 (A), J1.18, R2.2, R8.1
/~RST: J1.40, R4.2, R9.1, S1.B
GND: 12V-Battery1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.6, J1.9, J1.14, J1.20, J1.25, J1.30, J1.34, J1.39, J2.4 (GND), J2.5 (Shield), J3.2, J4.2, J5.3, Q1.2 (S), R5.2, R6.2, R7.2, R8.2, R10.2, R11.2, R12.2, R13.2, R14.2, S1.2, S1.A, SENSOR1.3, SENSOR2.3, U1.1 (GND), U1.7 (GND)
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (K), R10.1
unnamed: D4.1 (K), R11.1
unnamed: D5.3 (K1), R12.1
unnamed: D5.4 (K2), R14.1
unnamed: Q1.1 (G), R9.2
unnamed: Q1.3 (D), R3.2, S1.1
unnamed: R1.1, SENSOR1.2
unnamed: R2.1, SENSOR2.2
unnamed: R13.1, U1.4 (VO_Adj)

Notes on the sheet:
Power Input
5V Regulation
Power LEDs
Raspy
Sensors
Status LED
Reset Button
FAN
5V LED strip
12V LED strip
USB
