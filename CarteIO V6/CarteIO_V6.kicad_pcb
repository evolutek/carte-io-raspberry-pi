# Repository evolutek/carte-io-raspberry-pi (continued)

## KiCad design CarteIO Beacon V2/CarteIO Beacon V2.kicad_pcb (continued)

Board: 2 copper layers, 56.0 x 85.0 mm, 37 parts (8 on the bottom side), 21 nets.

## Commit log

2019-01-08 Add Lib
2019-01-08 Add Carte IO V1
2019-01-09 Add Components in the lib
2019-01-09 Add 12V regulator on the sch
2019-01-09 Add components to the lib
2019-01-09 Add GTB ports
2019-01-09 Add txt file for gpio
2019-01-11 Finish Schematics
2019-01-11 Pcb not finished
2019-01-15 PCB is done, need to check serial connector
2019-01-15 Update gitignore
2019-01-15 Finish Board and remove useless files
2019-01-15 Add Documentation
2019-03-12 Add Carte IO v2
2019-03-12 Add leds and correct mistakes on serial connection
2019-03-12 Add JST6 and correct wago connector
2019-03-14 Add V2 of the IO board
2019-03-17 Clean files and add Gerber files for V2
2019-12-26 Update Lib
2019-12-26 [V3] Add a new version, need to check and make 3D model
2019-12-28 [V3] Add 3D model, card checked
2020-01-24 [V3.0] Release
2020-01-24 [3.0] Release
2020-03-21 [3.2] Release
2020-03-29 [V3.2] Patch error on PCB
2020-04-10 [V3.2] Change led strip port and add a color sensor port
2020-04-16 [V3.2] Correct a bad routing on color sensor 1
2020-04-20 [V3.2] Correct I2C Multiplexer rooting
2020-09-04 CarteIO Beacon V1 + Add lib SEAL
2020-09-18 Added PDFs for Beacon shield
2021-01-03 Started shield IO v4
2021-01-03 Schematic almost done
2021-01-05 Started second disposition
2021-01-05 CarteIO V4 PCB almost done
2021-01-07 Third version of the shield IO v4
2021-01-07 Planes improvements
2021-01-07 Some fixes on V4.0 board
2021-01-12 Fixes
2021-01-14 Added 3.3V LDO + Lidar connector
2021-01-24 Added buzzer and power board conn, started rerouting
2021-01-24 Add 3D model of the V4.0
2021-01-25 Bottom of the PCB done
2021-01-28 Shield IO V4 done
2021-01-31 Bom, gerber, pdf, step
2021-02-28 Big 5V to CAN + Fixed bicolor led
2021-03-28 Pulldown Buzzer pin
2021-03-29 Shield V4.1
2021-03-31 Fixes V1.1 + 3rd CAN
2021-04-01 Release V4.1
2021-04-05 Add CarteIO Beacon V2
2021-04-05 Update production files
2021-04-05 Update production file for V4
2021-04-05 Update production file for CarteIO Beacon V2
2021-04-06 Minor fix
2022-03-16 Release V5
2022-05-01 Fix V5
2022-06-15 Add bom
2023-03-04 Wip V6
2023-03-05 Wip V6.0
2023-03-06 First version of V6.0
2023-03-08 Add comment in schematics and add CM logo
2023-03-08 Release V6.0
2023-03-15 Fix bom
2023-07-21 Carte IO Beacon V3.1
2023-07-29 Add Camera Aux connector to Carte IO Beacon V3
2023-08-18 Add jumper to select output voltage of the Camera Aux connector
2023-08-18 Add filtering for connected signal
2024-03-09 Carte IO Beacon V3.3
2024-03-17 Carte IO V6.1
2024-03-17 Fix prod archive
2024-03-17 Add decoupling on OR gate VCC
2024-03-18 Carte IO Coffee Pot V1.0
2024-03-18 Regenerate schematics
2024-03-22 Fix Panel IO Led mapping
2024-08-18 WIP Carte IO Beacon V4.0
2024-08-19 WIP V4.0
2024-12-14 Release V6.2
2024-12-19 minor tweaks
    BUS EVO connectors are too close to one another
2024-12-19 moved bus evo further appart from eachothr
2026-04-07 Release Carte IO RPI V6.3
2026-04-08 Add missing pulldown resistors
